# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M481LE8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.6
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: test +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.2.0, CMSIS:DSP 1.6.0, CMSIS:NN Lib 1.1.0, CMSIS Driver:Flash:AT45DB641E 1.3.0, Device:Startup 0.00.001
